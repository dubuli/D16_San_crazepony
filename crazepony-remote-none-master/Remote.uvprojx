# Keil uVision project Remote.uvprojx, settings and files
target Remote (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: remote +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\StartUp;.\User_Src;.\Lib\inc;.\HardWareDriver\BMP085;.\HardWareDriver\C;.\HardWareDriver\H;.\Control\C;.\Control\H
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./StartUp/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group HardWareDriver
    ./HardWareDriver/C/: delay.c Led.c Tim.c NRF24L01.c stmflash.c UART1.c adc.c Key.c SPI.c
  group User_Src
    ./User_Src/: main.c stm32f10x_it.c Sys_Fun.c ConfigTable.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_pwr.c stm32f10x_exti.c
  group Control
    ./Control/C/: Control.c CommUAV.c
software components: CMSIS:CORE 5.0.1
